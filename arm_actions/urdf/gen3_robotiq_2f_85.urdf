Commit message: added robotiq 2f85 mass to the bracelet_link

File: arm_actions/urdf/gen3_robotiq_2f_85.urdf (robot description, URDF)
Before this commit: robot gen3_robotiq_2f_85, 24 links, 23 joints
Links:
- link bracelet_link: mass 0.5 -> 1.425
